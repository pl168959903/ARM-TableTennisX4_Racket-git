# Keil uVision project TableTennisX4_Racket.uvprojx, settings and files
target TableTennisX4_Racket (6150000::V6.15::ARMCLANG)
  device: M032SG8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.8
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: TableTennisX4_Racket
  c flags: Optim=1 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  c misc: -Wno-unknown-attributes
  c include: ..\..\ARM-M031_BSP\CMSIS\Include;..\..\ARM-M031_BSP\Device\Nuvoton\M031\Include;..\..\ARM-M031_BSP\StdDriver\inc;.\MCU_Setup\clockConfig;.\MCU_Setup\pinConfig;.\Source\inc;..\..\External\nRF24L01P;..\..\External\vMemXorLinkList
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../../ARM-M031_BSP/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../ARM-M031_BSP/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../ARM-M031_BSP/StdDriver/src/: adc.c clk.c crc.c fmc.c gpio.c i2c.c pdma.c retarget.c rtc.c spi.c sys.c timer.c uart.c usbd.c wdt.c wwdt.c
  group User
    ./Source/src/: main.c
  group MCU_Setup
    ./MCU_Setup/clockConfig/: clockConfig.c
    ./MCU_Setup/pinConfig/: pinConfig.c
  group User_library
    ../../External/vMemXorLinkList/: vMemXor.c
    ../../External/nRF24L01P/: nRF24L01_drv_hook.c nRF24L01.c nRF24L01_Base.c
